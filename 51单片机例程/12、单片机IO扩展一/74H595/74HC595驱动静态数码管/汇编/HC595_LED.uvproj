# Keil uVision project HC595_LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6759 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(40000000) XRAM (0-0xFF) MODDP2
  output: HC595_LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: HC595_LED.asm
