# Keil uVision project AllFun.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: mainfun.c system.c Motor.c VI2C_C51.c AD_DA.c
